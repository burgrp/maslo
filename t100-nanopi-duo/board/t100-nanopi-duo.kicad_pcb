# Repository burgrp/maslo

File README.md:

TODO:
  - speed to duty lookup table
  - improve duty ramp
  - origin switch (sled/follow/target/fixed?)
  - error messages on UI
  - motor stop watchdog

## KiCad design t100-nanopi-duo/board/t100-nanopi-duo.kicad_pcb

Parts:
C1, C2: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 100n; C_0805_2012Metric
D1: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_B_Micro; conn_usb_B_micro_smd-2
J2: UART; PinHeader_1x03_P2.54mm_Horizontal
J4: T100-IN; PinHeader_1x10_P2.54mm_Horizontal
J5: T100-OUT; PinSocket_1x10_P2.54mm_Horizontal
M1: NanoPi-Duo
R1, R2, R3, R4: 1K5; R_0805_2012Metric
R5: 270R; R_0805_2012Metric
U1: CH330N; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: D1.2 (A), J4.6 (3V3), J5.6 (3V3), R1.2, R2.2, R3.2, R4.2
+5V: J4.7 (5V), J5.7 (5V), M1.15 (5VIN), M1.16 (5VIN)
+12V: J4.8 (12V), J4.9 (12V), J5.8 (12V), J5.9 (12V)
/IRQ: J4.4 (IRQ), J5.4 (IRQ), M1.23 (UART3-RX/SPI1-CLK/IO14), R3.1, R5.1
/MY_RXD: J2.3, M1.17 (UART0-RX/PWM0/IO5), U1.6 (TXD)
/MY_TXD: J2.2, M1.18 (UART0-TX/IO4), U1.7 (RXD)
/RST: C3.2, J4.5 (RST), J5.5 (RST), M1.22 (UART3-TX/SPI1-CS/IO13), R4.1
/SCL: J4.2 (SCL), J5.2 (SCL), M1.20 (I2C0-SCL/IO11), R1.1
/SDA: J4.3 (SDA), J5.3 (SDA), M1.21 (I2C0-SDA/IO12), R2.1
GND: C1.2, C2.2, C3.1, J1.5 (GND), J1.6 (Shield), J2.1, J4.1 (GND), J4.10 (GND), J5.1 (GND), J5.10 (GND), M1.13 (GND), M1.19 (GND), U1.3 (GND)
unnamed: C1.1, J1.1 (VBUS), U1.5 (VCC)
unnamed: C2.1, U1.8 (V3)
unnamed: D1.1 (K), R5.2
unnamed: J1.2 (D-), U1.2 (UD-)
unnamed: J1.3 (D+), U1.1 (UD+)

Board: 2 copper layers, 30.0 x 100.0 mm, 15 parts (0 on the bottom side), 15 nets.

## KiCad design t100-psu/board/t100-psu.kicad_pcb

Parts:
C1, C2, C7, C8: 100u/12V; CP_Elec_6.3x5.4
C3, C4, C5, C6: 100n; C_0805_2012Metric
D1: WHITE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Conn_01x02_Female; DG235-3.81-02P
J2: T100-IN; PinHeader_1x10_P2.54mm_Horizontal
J3: T100-OUT; PinSocket_1x10_P2.54mm_Horizontal
L1, L2: 6.8uH; CKCS6028
R1: 1k5; R_0805_2012Metric
R2, R3: 100k; R_0805_2012Metric
R4: 30.9k 1%; R_0805_2012Metric
R5: 4.22k 1%; R_0805_2012Metric
R6: 30k 1%; R_0805_2012Metric
R7: 6.65k 1%; R_0805_2012Metric
U1, U2: FR8205; SOT-23-6

Connections:
+3V3: C8.1, D1.2 (A), J2.6 (3V3), J3.6 (3V3), L2.2, R6.2
+5V: C7.1, J2.7 (5V), J3.7 (5V), L1.2, R4.2
+12V: C1.1, C2.1, C3.2, C4.2, J1.2, J2.8 (12V), J2.9 (12V), J3.8 (12V), J3.9 (12V), R2.2, R3.2, U1.5 (VIN), U2.5 (VIN)
/IRQ: J2.4 (IRQ), J3.4 (IRQ)
/RST: J2.5 (RST), J3.5 (RST)
/SCL: J2.2 (SCL), J3.2 (SCL)
/SDA: J2.3 (SDA), J3.3 (SDA)
GND: C1.2, C2.2, C3.1, C4.1, C7.2, C8.2, J1.1, J2.1 (GND), J2.10 (GND), J3.1 (GND), J3.10 (GND), R1.2, R5.1, R7.1, U1.2 (GND), U2.2 (GND)
unnamed: C5.1, U1.1 (BST)
unnamed: C5.2, L1.1, U1.6 (LX)
unnamed: C6.1, U2.1 (BST)
unnamed: C6.2, L2.1, U2.6 (LX)
unnamed: D1.1 (K), R1.1
unnamed: R2.1, U1.4 (SHDN)
unnamed: R3.1, U2.4 (SHDN)
unnamed: R4.1, R5.2, U1.3 (FB)
unnamed: R6.1, R7.2, U2.3 (FB)

Board: 2 copper layers, 25.0 x 100.0 mm, 23 parts (0 on the bottom side), 17 nets.

## KiCad design t100-usb/board/t100-usb.kicad_pcb

Parts:
C1, C2, C3: 100n; C_0805_2012Metric
D1: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_B_Micro; conn_usb_B_micro_smd-2
J2: T100-IN; PinHeader_1x10_P2.54mm_Horizontal
J3: T100-OUT; PinSocket_1x10_P2.54mm_Horizontal
R1, R2, R3, R4: 1K5; R_0805_2012Metric
R5, R6: 270R; R_0805_2012Metric
U1: ATSAMD11C14A-SS; SOIC-14_3.9x8.7mm_P1.27mm
X1: SWD

Connections:
+3V3: C1.2, D2.2 (A), J2.6 (3V3), J3.6 (3V3), R1.2, R2.2, R3.2, R4.2, U1.12 (VDD)
+5V: J2.7 (5V), J3.7 (5V)
+12V: J2.8 (12V), J2.9 (12V), J3.8 (12V), J3.9 (12V)
/I2C_ACT: R5.1, U1.13 (PA02)
/IRQ: J2.4 (IRQ), J3.4 (IRQ), R3.1, R6.1, U1.1 (PA05)
/RST: C3.2, J2.5 (RST), J3.5 (RST), R4.1, U1.14 (PA04)
/SCL: J2.2 (SCL), J3.2 (SCL), R1.1, U1.5 (PA15)
/SDA: J2.3 (SDA), J3.3 (SDA), R2.1, U1.4 (PA14)
/SWCLK: U1.7 (PA30/SWCLK), X1.3 (SWCLK)
/SWDIO: U1.8 (PA31/SWDIO), X1.1 (SWDIO)
/USB_DM: J1.2 (D-), U1.9 (PA24)
/USB_DP: J1.3 (D+), U1.10 (PA25)
GND: C1.1, C2.1, C3.1, D1.1 (K), J1.5 (GND), J1.6 (Shield), J2.1 (GND), J2.10 (GND), J3.1 (GND), J3.10 (GND), U1.11 (GND)
unnamed: C2.2, U1.6 (PA28/~RST)
unnamed: D1.2 (A), R5.2
unnamed: D2.1 (K), R6.2

Board: 2 copper layers, 20.0 x 100.0 mm, 15 parts (0 on the bottom side), 14 nets.

## KiCad design t100-relay/board/t100-relay.kicad_pcb

Parts:
C1: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: SK22; D_SMB_Handsoldering
J1: T100-IN; PinHeader_1x10_P2.54mm_Horizontal
J2: T100-OUT; PinSocket_1x10_P2.54mm_Horizontal
J3, J4: Conn_01x02_Female; DG235-3.81-02P
JP1: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
K1: RELAY_1; SRD_C_Relay
Q1: BC817; SOT-23
R1: 270R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 1k5; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ATSAMD09C13A-SS; SOIC-14_3.9x8.7mm_P1.27mm
X1: SWD

Connections:
+3V3: C1.1, J1.6 (3V3), J2.6 (3V3), JP1.1 (A), U1.12 (VDD)
+5V: D2.1 (K), J1.7 (5V), J2.7 (5V), K1.1 (C2)
+12V: J1.8 (12V), J1.9 (12V), J2.8 (12V), J2.9 (12V)
/ADDR: JP1.2 (C), U1.13 (PA02)
/IRQ: J1.4 (IRQ), J2.4 (IRQ), U1.9 (PA24)
/LED: R1.2, U1.14 (PA04)
/RELAY: R2.1, U1.1 (PA05)
/RST: J1.5 (RST), J2.5 (RST), U1.6 (PA28/~RST)
/SCL: J1.2 (SCL), J2.2 (SCL), U1.5 (PA15)
/SDA: J1.3 (SDA), J2.3 (SDA), U1.4 (PA14)
/SWCLK: U1.7 (PA30/SWCLK), X1.3 (SWCLK)
/SWDIO: U1.8 (PA31/SWDIO), X1.1 (SWDIO)
GND: C1.2, D1.1 (K), J1.1 (GND), J1.10 (GND), J2.1 (GND), J2.10 (GND), JP1.3 (B), Q1.2 (E), U1.11 (GND), X1.2 (GND)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), K1.4 (C1), Q1.3 (C)
unnamed: J3.1, J4.1
unnamed: J3.2, K1.5 (A)
unnamed: J4.2, K1.2 (B)
unnamed: Q1.1 (B), R2.2

Board: 2 copper layers, 20.0 x 100.0 mm, 14 parts (0 on the bottom side), 19 nets.

## KiCad design t100-dcmotor/board/t100-dcmotor.kicad_pcb

Board: 2 copper layers, 35.0 x 100.0 mm, 34 parts (0 on the bottom side), 27 nets.

Parts:
C1, C3, C4: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 100u/16V; CP_Elec_6.3x5.4
C5, C6, C7, C8: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2, D3, D4, D5: BAT54S; SOT-23
FB1: 600R/500mA; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: T100-IN; PinHeader_1x10_P2.54mm_Horizontal
J2: T100-OUT; PinSocket_1x10_P2.54mm_Horizontal
J3: Conn_01x08_Female; DG235-3.81-08P
JP1: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
R1, R2, R4, R6, R8: 270R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R5, R7, R9: 1k5; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R11: 0R47; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
ST1, ST2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
U1: ATSAMD11D14A-SS; SOIC-20W_7.5x12.8mm_P1.27mm
U2: TB67H451FNG; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm
X1: SWD

Connections:
+3V3: C1.1, C3.1, D2.2, D3.2, D4.2, D5.2, J1.6 (3V3), J2.6 (3V3), JP1.1 (A), R3.1, R5.1, R7.1, R9.1, U1.17 (VDD), U2.4 (VREF)
+5V: FB1.2, J1.7 (5V), J2.7 (5V)
+12V: C2.1, C4.1, J1.8 (12V), J1.9 (12V), J2.8 (12V), J2.9 (12V), U2.5 (VM)
/ADDR: JP1.2 (C), U1.19 (PA03)
/HALL_A: C6.1, D3.3, R4.1, R5.2, U1.2 (PA06)
/HALL_B: C5.1, D2.3, R2.1, R3.2, U1.3 (PA07)
/IRQ: J1.4 (IRQ), J2.4 (IRQ), U1.10 (PA23)
/LED: R1.2, U1.14 (PA24)
/MOTOR_1: U1.8 (PA16), U2.2 (IN1)
/MOTOR_2: U1.9 (PA22), U2.3 (IN2)
/MOTOR_M: J3.1, U2.6 (OUT1)
/MOTOR_P: J3.6, U2.8 (OUT2)
/RST: J1.5 (RST), J2.5 (RST), U1.11 (PA28/~RST)
/SCL: J1.2 (SCL), J2.2 (SCL), U1.7 (PA15)
/SDA: J1.3 (SDA), J2.3 (SDA), U1.6 (PA14)
/STOP_1: C7.1, D4.3, R6.1, R7.2, ST1.1 (A), U1.20 (PA04)
/STOP_2: C8.1, D5.3, R8.1, R9.2, ST2.1 (A), U1.1 (PA05)
/SWCLK: U1.12 (PA30/SWCLK), X1.3 (SWCLK)
/SWDIO: U1.13 (PA31/SWDIO), X1.1 (SWDIO)
/input-filter1/PORT: J3.4, R4.2
/input-filter2/PORT: J3.7, R6.2
/input-filter3/PORT: J3.8, R8.2
/input-filter/PORT: J3.3, R2.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), D2.1, D3.1, D4.1, D5.1, J1.1 (GND), J1.10 (GND), J2.1 (GND), J2.10 (GND), J3.2, JP1.3 (B), R10.1, R11.1, ST1.2 (B), ST2.2 (B), U1.16 (GND), U2.1 (GND), U2.9 (GND), X1.2 (GND)
unnamed: D1.2 (A), R1.1
unnamed: FB1.1, J3.5
unnamed: R10.2, R11.2, U2.7 (RS)

## KiCad design t100-raspi/board/t100-raspi.kicad_pcb

Parts:
C1, C2: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4, C9, C10: 100u/12V; CP_Elec_6.3x5.4
C5, C6, C7, C8: 100n; C_0805_2012Metric
J1: USB_B_Micro; conn_usb_B_micro_smd-2
J2: UART; PinHeader_1x03_P2.54mm_Vertical
J3: Raspberry_Pi_2_3; Raspberry-PI-3-B-vertical
J4: 12V; DG301-5.0-02
J5: T100-OUT; PinSocket_1x12_P2.54mm_Horizontal
L1, L2: 6.8uH; CKCS6028
R1, R2: 100k; R_0805_2012Metric
R3, R4, R5, R6: 1K5; R_0805_2012Metric
R7: 30k 1%; R_0805_2012Metric
R8: 6.65k 1%; R_0805_2012Metric
R9: 30.9k 1%; R_0805_2012Metric
R10: 4.22k 1%; R_0805_2012Metric
U1: CH330N; SOIC-8_3.9x4.9mm_P1.27mm
U2, U3: FR8205; SOT-23-6

Connections:
+3V3: C9.1, J5.6, L1.2, R3.2, R4.2, R5.2, R6.2, R7.2
+5V: C10.1, J3.2 (5V), J3.4 (5V), J5.8, L2.2, R9.2
+12V: C3.1, C4.1, C5.2, C6.2, J4.2, J5.10, J5.11, R1.2, R2.2, U2.5, U3.5
/IRQ: J3.29 (GCLK1/GPIO5), J5.4, R5.1
/MY_RXD: J2.3, J3.10 (GPIO15/RXD), U1.6 (TXD)
/MY_TXD: J2.2, J3.8 (GPIO14/TXD), U1.7 (RXD)
/SCL: J3.5 (SCL/GPIO3), J5.2, R3.1
/SDA: J3.3 (SDA/GPIO2), J5.3, R4.1
/TRG: J3.31 (GCLK2/GPIO6), J5.5, R6.1
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C9.2, C10.2, J1.5 (GND), J1.6 (Shield), J2.1, J3.6 (GND), J3.9 (GND), J3.14 (GND), J3.20 (GND), J3.25 (GND), J3.30 (GND), J3.34 (GND), J3.39 (GND), J4.1, J5.1, J5.7, J5.9, J5.12, R8.1, R10.1, U1.3 (GND), U2.2, U3.2
unnamed: C1.1, J1.1 (VBUS), U1.5 (VCC)
unnamed: C2.1, U1.8 (V3)
unnamed: C7.1, U2.1
unnamed: C7.2, L1.1, U2.6
unnamed: C8.1, U3.1
unnamed: C8.2, L2.1, U3.6
unnamed: J1.2 (D-), U1.2 (UD-)
unnamed: J1.3 (D+), U1.1 (UD+)
unnamed: R1.1, U2.4
unnamed: R2.1, U3.4
unnamed: R7.1, R8.2, U2.3
unnamed: R9.1, R10.2, U3.3

Board: 2 copper layers, 49.5 x 99.5 mm, 30 parts (0 on the bottom side), 22 nets.

## KiCad design t100-dcmotor/t100-dcmotor.kicad_pcb

Parts:
C1, C3: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 270p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2, D3: BAT54S; SOT-23
FB1: 600R/500mA; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: T100-IN; PinHeader_1x12_P2.54mm_Horizontal
J2: T100-OUT; PinSocket_1x12_P2.54mm_Horizontal
J3: Conn_01x08_Female; DG235-3.81-08P
R1, R10, R11: 270R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3, R4, R5: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R7, R8, R14, R15: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R9: (sense?); R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12: A-270R B-N/A Z-10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13: A-N/A B-270R Z-10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: ATSAMD11D14A-SS; SOIC-20W_7.5x12.8mm_P1.27mm
U2: VNH7070BAS; SOIC-16_3.9x9.9mm_P1.27mm
X1: SWD

Connections:
+3V3: C1.1, D2.2, D3.2, J1.6 (3V3), J2.6 (3V3), R7.2, R8.2, R12.1, R14.2, R15.2, U1.17 (VDD)
+5V: FB1.2, J1.8 (5V), J2.8 (5V)
+12V: C3.1, C4.1, J1.10 (12V), J1.11 (12V), J2.10 (12V), J2.11 (12V), U2.4 (VCC), U2.5 (VCC), U2.12 (VCC)
/ADDR: R12.2, R13.1, U1.19 (PA03)
/CS: C2.1, R6.2, U1.18 (PA02)
/HALL_A: D3.3, R8.1, R11.2, U1.2 (PA06)
/HALL_B: D2.3, R7.1, R10.2, U1.3 (PA07)
/INA: R2.2, U1.14 (PA24)
/INB: R3.2, U1.15 (PA25)
/IRQ: J1.4 (IRQ), J2.4 (IRQ), U1.1 (PA05)
/LED: R1.2, U1.9 (PA22)
/MOTOR_M: J3.1, U2.7 (OUTB), U2.10 (OUTB)
/MOTOR_P: J3.6, U2.2 (OUTA), U2.15 (OUTA)
/PWM: R4.2, U1.8 (PA16)
/SCL: J1.2 (SCL), J2.2 (SCL), U1.7 (PA15)
/SDA: J1.3 (SDA), J2.3 (SDA), U1.6 (PA14)
/SEL0: R5.2, U1.10 (PA23)
/STOP_1: J3.7, R14.1, U1.4 (PA08/XIN)
/STOP_2: J3.8, R15.1, U1.5 (PA09/XOUT)
/SWCLK: U1.12 (PA30/SWCLK), X1.3 (SWCLK)
/SWDIO: U1.13 (PA31/SWDIO), X1.1 (SWDIO)
/TRG: J1.5 (TRG), J2.5 (TRG), U1.20 (PA04)
GND: C1.2, C2.2, C3.2, C4.2, D1.1 (K), D2.1, D3.1, J1.1 (GND), J1.7 (GND), J1.9 (GND), J1.12 (GND), J2.1 (GND), J2.7 (GND), J2.9 (GND), J2.12 (GND), J3.2, R9.1, R13.2, U1.16 (GND), U2.1 (GNDA), U2.8 (GNDB), U2.9 (GNDB), U2.16 (GNDA), X1.2 (GND)
unnamed: D1.2 (A), R1.1
unnamed: FB1.1, J3.5
unnamed: J3.3, R10.1
unnamed: J3.4, R11.1
unnamed: R2.1, U2.3 (INA)
unnamed: R3.1, U2.6 (INB)
unnamed: R4.1, U2.11 (PWM)
unnamed: R5.1, U2.14 (SEL0)
unnamed: R6.1, R9.2, U2.13 (CS)

Notes on the sheet:
pullup k STOP1/2
zmenit velikost R7, R8

Board: 2 copper layers, 34.5 x 99.5 mm, 29 parts (0 on the bottom side), 32 nets.

## KiCad design t100-usb/t100-usb.kicad_pcb

Board: 2 copper layers, 34.5 x 99.5 mm, 37 parts (0 on the bottom side), 25 nets.

Parts:
C1, C4, C5, C19: 100u/12V; CP_Elec_6.3x5.4
C2, C3, C8, C11, C18: 100n; C_0805_2012Metric
C6: 47M; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7: 220n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DG1: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DR1: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DW1: WHITE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DY1: YELLOW; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Conn_01x02_Female; DG301-5.0-02
J2: USB_B_Micro; conn_usb_B_micro_smd-2
J3: T100-OUT; PinSocket_1x12_P2.54mm_Horizontal
L1, L3: 6.8uH; CKCS6028
R1, R5: 100k; R_0805_2012Metric
R2: 30k 1%; R_0805_2012Metric
R3: 6.65k 1%; R_0805_2012Metric
R4, R12, R13, R14: 270R; R_0805_2012Metric
R6: 30.9k 1%; R_0805_2012Metric
R7: 4.22k 1%; R_0805_2012Metric
R8, R9, R10, R11: 1K5; R_0805_2012Metric
U1, U2: FR8205; SOT-23-6
U3: MCP2221A; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3V3: C5.1, DG1.2, DR1.2, DW1.2, DY1.2, J3.6, L1.2, R2.2, R8.2, R9.2, R10.2, R11.2
+5V: C19.1, J3.8, L3.2, R6.2
+12V: C1.1, C2.2, C4.1, C11.2, J1.2, J3.10, J3.11, R1.2, R5.2, U1.5, U2.5
/I2C_ACT: R4.1, U3.8
/IRQ: J3.4, R10.1, R13.1, U3.2
/SCL: J3.2, R8.1, U3.10
/SDA: J3.3, R9.1, U3.9
/TRG: J3.5, R11.1, R14.1, U3.3
GND: C1.2, C2.1, C4.2, C5.2, C6.2, C7.2, C8.1, C11.1, C19.2, J1.1, J2.5, J2.6, J3.1, J3.7, J3.9, J3.12, R3.1, R7.1, R12.2, U1.2, U2.2, U3.14
unnamed: C3.1, U2.1
unnamed: C3.2, L1.1, U2.6
unnamed: C6.1, C8.2, J2.1, U3.1
unnamed: C7.1, U3.11
unnamed: C18.1, U1.1
unnamed: C18.2, L3.1, U1.6
unnamed: DG1.1, R14.2
unnamed: DR1.1, R13.2
unnamed: DW1.1, R12.1
unnamed: DY1.1, R4.2
unnamed: J2.2, U3.12
unnamed: J2.3, U3.13
unnamed: R1.1, U2.4
unnamed: R2.1, R3.2, U2.3
unnamed: R5.1, U1.4
unnamed: R6.1, R7.2, U1.3
